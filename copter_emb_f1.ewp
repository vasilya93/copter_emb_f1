# IAR project copter_emb_f1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD
  ICCARM.CCIncludePath2: .\CMSIS; ..\CMSIS; .\lib; ..\lib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group src
    src/: main.c
  group src/CMSIS
    src/CMSIS/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group src/lib
    src/lib/: Buffer.c Buffer.h ClockControl.c ClockControl.h controller.c controller.h fifo.c fifo.h fifo_impl.h fifo_int16.c fifo_int16.h helper.c helper.h HMC5883.c HMC5883.h I2C.c I2C.h Messenger.c Messenger.h motors.c motors.h MPU6050.c MPU6050.h PWM.c PWM.h sensors_fusion.c sensors_fusion.h Serial.c Serial.h settings.h Timer.c Timer.h USART.c USART.h vector.c vector.h Wire.c Wire.h
  group src/startup
    src/startup/: startup_stm32f10x_md_vl.s
